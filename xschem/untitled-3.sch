v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} -70 -10 0 0 {name=R4
L=10
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
